FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-add-my-print.patch"
#SRC_URI += "file://kernelconfig.cfg"
